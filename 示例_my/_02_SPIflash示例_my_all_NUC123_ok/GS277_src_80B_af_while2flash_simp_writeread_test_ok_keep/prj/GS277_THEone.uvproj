# Keil uVision project GS277_THEone.uvproj, settings and files
target THEone (ARM-ADS)
  device: NUC123LC2AN1 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x8FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: THEone +hex
  AfterMake: fromelf --bin ".\output\@L.axf" --output ".\output\@L.bin"
  AfterMake: fromelf --text -c ".\output\@L.axf" --output ".\output\@L.txt"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c misc: --asm --info=totals --min_array_alignment=4
  c include: ..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC123Series;..\CMSIS\CM0\CoreSupport;..\INC\DrvInc;..\INC\SysInc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_NUC123Series.o(RESET)' --datacompressor=off --info=inline
  group cmsis
    ../cmsis/CM0/CoreSupport/: core_cm0.c
    ../cmsis/CM0/DeviceSupport/Nuvoton/NUC123Series/: system_NUC123Series.c
    ../cmsis/CM0/DeviceSupport/Nuvoton/NUC123Series/startup/arm/: startup_NUC123Series.s
  group DrvSrc
    ../DrvSrc/: DrvADC.c DrvFMC.c DrvI2C.c DrvI2S.c DrvPDMA.c DrvPWM.c DrvSPI.c DrvSYS.c DrvTimer.c DrvUART.c
  group AppSrc
    ../AppSrc/: adcKey.c appKey.c config.c i2cSys.c irKey.c led.c main.c power.c seW58.c SysTimerTask.c test.c mypdma.c i2s_spi.c filter.c sta339.c 74HC4094.c cs8422.c csr_module.c uart.c DWHP83.c gsensor.c pcm5121.c
    ../DrvSrc/: retarget.c
  group DrvInc
    ../INC/DrvInc/: ADC.h CLOCK.h CRC.h DrvUSB.h FMC.h GPIO.h I2C.h I2S.h PDMA.h PS2.h PWM.h SPI.h SYS.h TIMER.h UART.h USB.h WDT.h WWDT.h
    ../INC/SysInc/: sta339.h
  group SysInc
    ../INC/SysInc/: adcKey.h appKey.h config.h debug.h filter.h filter_config.h i2cSys.h irKey.h led.h mypdma.h power.h seW58.h sysinc.h SysTimerTask.h test.h typedef.h limiter.h i2s_spi.h gsensor.h 74hc4096.h cs8422.h csr_module.h sta339.h uart.h pcm5121.h
