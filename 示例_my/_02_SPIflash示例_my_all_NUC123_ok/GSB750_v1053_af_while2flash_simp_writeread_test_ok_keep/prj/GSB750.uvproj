# Keil uVision project GSB750.uvproj, settings and files
target GSB750 (ARM-ADS)
  device: NUC123LC2AN1 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x8FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: GSB750 +hex
  AfterMake: fromelf --bin ".\output\@L.axf" --output ".\output\@L.bin"
  AfterMake: fromelf --text -c ".\output\@L.axf" --output ".\output\@L.txt"
  c flags: OneElfS=1
  c misc: --asm --info=totals
  c include: ..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC123Series;..\CMSIS\CM0\CoreSupport;..\INC\DrvInc;..\INC\SysInc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT5: ROM 0x8000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x2800
  memory RVCT10: RAM 0x20002800 size 0x800
  link misc: --map --first='startup_NUC123Series.o(RESET)' --datacompressor=off --info=inline
  group cmsis
    ../cmsis/CM0/CoreSupport/: core_cm0.c
    ../cmsis/CM0/DeviceSupport/Nuvoton/NUC123Series/: system_NUC123Series.c
    ../cmsis/CM0/DeviceSupport/Nuvoton/NUC123Series/startup/arm/: startup_NUC123Series.s
  group DrvSrc
    ../DrvSrc/: DrvADC.c DrvFMC.c DrvI2C.c DrvI2S.c DrvPWM.c DrvSPI.c DrvSYS.c DrvTimer.c DrvUART.c
  group AppSrc
    ../AppSrc/: adcKey.c appKey.c config.c datalog.c debug.c DWHP83.c filter.c gsensor.c i2cSys.c i2s_spi.c led.c main.c power.c pt2314.c sta339.c SysTimerTask.c uart.c test.c irKey.c cap1298.c wb6084.c
  group DrvInc
    ../INC/DrvInc/: ADC.h CLOCK.h CRC.h DrvUSB.h FMC.h GPIO.h I2C.h I2S.h PDMA.h PS2.h PWM.h SPI.h SYS.h TIMER.h UART.h USB.h WDT.h WWDT.h
  group SysInc
    ../INC/SysInc/: ad83586.h adcKey.h appKey.h config.h datalog.h debug.h Dwhp80.h filter.h filter_config.h gsensor.h i2cSys.h i2s_spi.h irKey.h led.h limiter.h mypdma.h power.h pt2314.h sta339.h sysinc.h SysTimerTask.h test.h typedef.h uart.h
