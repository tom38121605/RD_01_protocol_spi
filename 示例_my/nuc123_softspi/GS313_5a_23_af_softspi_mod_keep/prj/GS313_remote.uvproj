# Keil uVision project GS313_remote.uvproj, settings and files
target GS313 (ARM-ADS)
  device: NUC123SD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x10FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: GS313 +hex
  AfterMake: fromelf --bin ".\output\@L.axf" --output ".\output\@L.bin"
  AfterMake: fromelf --text -c ".\output\@L.axf" --output ".\output\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --asm --info=totals
  c include: ..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC123Series;..\CMSIS\CM0\CoreSupport;..\INC\DrvInc;..\INC\SysInc;..\dw
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC123Series.o(RESET)' --datacompressor=off --info=inline
  group cmsis
    ../cmsis/CM0/CoreSupport/: core_cm0.c
    ../cmsis/CM0/DeviceSupport/Nuvoton/NUC123Series/: system_NUC123Series.c
    ../cmsis/CM0/DeviceSupport/Nuvoton/NUC123Series/startup/arm/: startup_NUC123Series.s
  group DrvSrc
    ../DrvSrc/: DrvADC.c DrvFMC.c DrvI2C.c DrvI2S.c DrvPWM.c DrvSPI.c DrvTimer.c DrvUART.c retarget.c DrvSYS.c
  group AppSrc
    ../AppSrc/: main.c uart.c SysTimerTask.c appKey.c adcKey.c i2cSys.c power.c led.c i2s_spi.c sta339.c config.c filter.c DWHP83.c cs8422.c 74HC4094.c
  group DrvInc
    ../INC/DrvInc/: ADC.h CLOCK.h CRC.h DrvUSB.h FMC.h GPIO.h I2C.h I2S.h PS2.h PWM.h SPI.h SYS.h TIMER.h UART.h USB.h WDT.h WWDT.h
  group SysInc
    ../INC/SysInc/: sysinc.h typedef.h uart.h SysTimerTask.h appKey.h adcKey.h i2cSys.h power.h led.h config.h 74hc4096.h filter.h i2s_spi.h sta339.h pt2314.h filter_config.h limiter.h dwhp83.h cs8422.h
    ../cmsis/CM0/DeviceSupport/Nuvoton/NUC123Series/: NUC123Series.h
  group dw1000
    ../dw/: deca_device.c deca_params_init.c deca_device_api.h deca_param_types.h deca_regs.h deca_types.h deca_version.h deca.c deca.h
